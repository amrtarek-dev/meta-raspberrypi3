# Set a root password
#MD5_ROOT_PASSWD = ""

# Image install
IMAGE_INSTALL += "\
"


# Image features adding
IMAGE_FEATURES += "\
    ssh-server-dropbear \
"
